Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: I:\A - PROJETO NOVO WORKSPACE\ENGENHARIA LUMINARIA\A - PROJETOS & DESENVOLVIMENTO\FLED SS-URB\EM ANDAMENTO\DESENHOS\MONTAGEM\PARA ENVIO\FLED SS-URB - 150W.IFC
Time: 2025-07-14T14:37:34+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
